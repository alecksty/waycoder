// 数组元素赋值：**值所在的那个寄存器被下标计算抢走**。
//
// ## 症状
//
// 循环里"边读边写"（`for (i=0; s[i]; i++) dst[n++] = s[i];` —— 教科书式的 strcpy 形状）
// 之后再写数组，**某些元素的值会变成"当时的 n"**：
//
//     for (i = 0; s[i] != 0; i++) { a[n++] = s[i]; }
//     a[n++] = 'A'; a[n++] = 'B'; a[n++] = 'C'; a[n++] = 'D'; a[n++] = 'z';
//
// 实测 `a = H E L L O A 6 C D z` —— 只有 `'B'`（66）变成了 **6**，
// 而 6 正是那一刻的 `n`。A/C/D/z 全对 ⇒ **不是"常量错了"，是"值丢了"**。
//
// ## 真身（读 `--vml` 产物）
//
//         move @R0 #66        ; 常量 66
//         move @R1 @R0        ; ← 先把值存进 R1（表达式结果暂存）
//         …                   ; 下标计算：读 n、n+1 写回、取旧 n
//         move @R1 @R0        ; ← **R1 在这里被抢去装 n**
//         …
//         moveb @0 @R1        ; ← 存下去的是 R1，早已不是 66，而是 n（=6）
//
// 即：**「值的暂存寄存器」与「下标计算的临时寄存器」撞了**。
// 为什么只有 'B' 中招：A/C/D/z 的值寄存器恰好落在 R4/R9/R5，而 B 落在 R1。
//
// ⚠ 触发面**不止 char 数组**：`int a[32]` 同样复现（值一样变 6）。
//
// ## 修法（同批修掉）
//
// `CodeGenerator.Expressions.cs` 的「`assignment.Target is ArrayAccess`」那一支：
// 它先 `AllocInt` 挑一个寄存器存值，再调 `GenerateArrayAddress` —— 而后者内部有
// **硬编码的 R1**（它自己的注释就写着"用栈保存基地址，避免与硬编码寄存器（R1）冲突"）。
// `AllocInt` 是从空闲表里取的，**R1 恰好空闲时就会把值的寄存器发成 R1** ⇒ 被踩。
// 现在在两步之间给值的寄存器加一对 `PUSH`/`POP`。
// **没有用 `ReserveInt(1)`**：压栈对"下标路径到底用哪几个寄存器"不敏感，
// 将来那边多硬编码一个 R2 也不会再坏一次。
//
// 判据挑的最小形状（少了任何一项都不复现，改的时候别把这几项改没了）：
//   ① 循环**条件**读 `s[i]`；
//   ② 循环**体**也读 `s[i]`（只满足其一的版本实测是对的，见 CHANGELOG v0.96.382 的二分）；
//   ③ 循环之后紧跟数组元素写入。
int main()
{
    char a[32];
    char s[] = "HELLO";
    int n = 0;
    int i;

    for (i = 0; s[i] != 0; i++)
    {
        a[n++] = s[i];
    }

    a[n++] = 'A';
    a[n++] = 'B';
    a[n++] = 'C';
    a[n++] = 'D';
    a[n++] = 'z';
    a[n] = 0;

    /* 逐字节报出来（不经过 stdio 的字符串函数 —— 名字里带 B 的东西一概绕开，
       免得把"值坏了"和"打印坏了"混在一起）。
       ⚠ 分隔符用**逗号**、且**不打在最后一项后面**：判据是按文本比对的，
       行尾多一个空格就会红，而"行尾空格"这种东西最容易被编辑器悄悄吃掉。 */
    print_str("n=");
    print_int(n);
    print_str(" =");
    for (i = 0; i < 12; i++)
    {
        if (i > 0) print_str(",");
        print_int(a[i]);
    }
    print_str("\n");
    return 0;
}

// EXPECT: n=10 =72,69,76,76,79,65,66,67,68,122,0,0
